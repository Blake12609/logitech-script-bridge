#include "keys.h"

#include <algorithm>
#include <cctype>

namespace {

const KeyInfo kKeys[] = {
    {"escape", 0x01, 0x29},
    {"1", 0x02, 0x1E}, {"2", 0x03, 0x1F}, {"3", 0x04, 0x20}, {"4", 0x05, 0x21},
    {"5", 0x06, 0x22}, {"6", 0x07, 0x23}, {"7", 0x08, 0x24}, {"8", 0x09, 0x25},
    {"9", 0x0A, 0x26}, {"0", 0x0B, 0x27},
    {"minus", 0x0C, 0x2D}, {"equal", 0x0D, 0x2E}, {"backspace", 0x0E, 0x2A},
    {"tab", 0x0F, 0x2B},
    {"q", 0x10, 0x14}, {"w", 0x11, 0x1A}, {"e", 0x12, 0x08}, {"r", 0x13, 0x15},
    {"t", 0x14, 0x17}, {"y", 0x15, 0x1C}, {"u", 0x16, 0x18}, {"i", 0x17, 0x0C},
    {"o", 0x18, 0x12}, {"p", 0x19, 0x13},
    {"lbracket", 0x1A, 0x2F}, {"rbracket", 0x1B, 0x30}, {"enter", 0x1C, 0x28},
    {"lctrl", 0x1D, 0xE0},
    {"a", 0x1E, 0x04}, {"s", 0x1F, 0x16}, {"d", 0x20, 0x07}, {"f", 0x21, 0x09},
    {"g", 0x22, 0x0A}, {"h", 0x23, 0x0B}, {"j", 0x24, 0x0D}, {"k", 0x25, 0x0E},
    {"l", 0x26, 0x0F},
    {"semicolon", 0x27, 0x33}, {"quote", 0x28, 0x34}, {"tilde", 0x29, 0x35},
    {"lshift", 0x2A, 0xE1}, {"backslash", 0x2B, 0x31},
    {"z", 0x2C, 0x1D}, {"x", 0x2D, 0x1B}, {"c", 0x2E, 0x06}, {"v", 0x2F, 0x19},
    {"b", 0x30, 0x05}, {"n", 0x31, 0x11}, {"m", 0x32, 0x10},
    {"comma", 0x33, 0x36}, {"period", 0x34, 0x37}, {"slash", 0x35, 0x38},
    {"rshift", 0x36, 0xE5}, {"numstar", 0x37, 0x55}, {"lalt", 0x38, 0xE2},
    {"spacebar", 0x39, 0x2C}, {"capslock", 0x3A, 0x39},
    {"f1", 0x3B, 0x3A}, {"f2", 0x3C, 0x3B}, {"f3", 0x3D, 0x3C}, {"f4", 0x3E, 0x3D},
    {"f5", 0x3F, 0x3E}, {"f6", 0x40, 0x3F}, {"f7", 0x41, 0x40}, {"f8", 0x42, 0x41},
    {"f9", 0x43, 0x42}, {"f10", 0x44, 0x43},
    {"numlock", 0x45, 0x53}, {"scrolllock", 0x46, 0x47},
    {"num7", 0x47, 0x5F}, {"num8", 0x48, 0x60}, {"num9", 0x49, 0x61},
    {"numminus", 0x4A, 0x56},
    {"num4", 0x4B, 0x5C}, {"num5", 0x4C, 0x5D}, {"num6", 0x4D, 0x5E},
    {"numplus", 0x4E, 0x57},
    {"num1", 0x4F, 0x59}, {"num2", 0x50, 0x5A}, {"num3", 0x51, 0x5B},
    {"num0", 0x52, 0x62}, {"numperiod", 0x53, 0x63},
    {"non_us_slash", 0x56, 0x64}, {"f11", 0x57, 0x44}, {"f12", 0x58, 0x45},
    {"f13", 0x64, 0x68}, {"f14", 0x65, 0x69}, {"f15", 0x66, 0x6A}, {"f16", 0x67, 0x6B},
    {"f17", 0x68, 0x6C}, {"f18", 0x69, 0x6D}, {"f19", 0x6A, 0x6E}, {"f20", 0x6B, 0x6F},
    {"f21", 0x6C, 0x70}, {"f22", 0x6D, 0x71}, {"f23", 0x6E, 0x72}, {"f24", 0x76, 0x73},
    {"numenter", 0x11C, 0x58}, {"rctrl", 0x11D, 0xE4}, {"numslash", 0x135, 0x54},
    {"printscreen", 0x137, 0x46}, {"ralt", 0x138, 0xE6}, {"pause", 0x146, 0x48},
    {"home", 0x147, 0x4A}, {"up", 0x148, 0x52}, {"pageup", 0x149, 0x4B},
    {"left", 0x14B, 0x50}, {"right", 0x14D, 0x4F}, {"end", 0x14F, 0x4D},
    {"down", 0x150, 0x51}, {"pagedown", 0x151, 0x4E}, {"insert", 0x152, 0x49},
    {"delete", 0x153, 0x4C}, {"lgui", 0x15B, 0xE3}, {"rgui", 0x15C, 0xE7},
    {"appkey", 0x15D, 0x65},
};

const struct { const char* alias; const char* name; } kAliases[] = {
    {"esc", "escape"}, {"space", "spacebar"}, {"return", "enter"},
    {"numdivide", "numslash"}, {"nummult", "numstar"}, {"numdecimal", "numperiod"},
    {"lwin", "lgui"}, {"rwin", "rgui"}, {"application", "appkey"},
    {"grave", "tilde"}, {"del", "delete"}, {"ins", "insert"},
};

}  // namespace

const KeyInfo* findKeyByName(const std::string& raw) {
    std::string name;
    for (char c : raw)
        if (!std::isspace(static_cast<unsigned char>(c)))
            name += static_cast<char>(std::tolower(static_cast<unsigned char>(c)));
    for (const auto& a : kAliases)
        if (name == a.alias) name = a.name;
    for (const auto& k : kKeys)
        if (name == k.name) return &k;
    return nullptr;
}

const KeyInfo* findKeyByScancode(int scancode) {
    for (const auto& k : kKeys)
        if (k.scancode == scancode) return &k;
    return nullptr;
}
